SUMMARY = "An image for the brutzelboy during development"
DESCRIPTION = "An image based on core-image-minimal with development and benchmark tools."
LICENSE = "MIT"

require brutzelboy.inc
